# IAR project modbus_motor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030C6 ST STM32F030C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.PreInclude: stm32f0xx_conf.h
  ICCARM.CCIncludePath2: ; src\; inc\; Libraries\STM32F0xx_StdPeriph_Driver\inc; Libraries\STM32F0xx_StdPeriph_Driver\src; Libraries\CMSIS\Device\ST\STM32F0xx\Include; Libraries\CMSIS\Include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.5\arm\CMSIS\Include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.3\arm\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: modbus_motor.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: stm32f0xx_conf.h
  group inc
    inc/: adc_dma.h gpio_macros.h hal.h modbus.h usart.h
  group Lib
    Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group src
    src/: adc_dma.c hal.c modbus.c usart.c
    ./: main.c
